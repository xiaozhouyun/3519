# Keil uVision project empty_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3519_freertos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3519_freertos_keil +hex
  BeforeMake: D:\ti\mspm0_sdk_2_11_00_07\tools\keil\syscfg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../;../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;D:\ti\mspm0_sdk_2_11_00_07\source;D:\ti\mspm0_sdk_2_11_00_07\source\third_party\CMSIS\Core\Include;../freertos/Source/include;../freertos/Source/portable/GCC/ARM_CM0;../freertos/builds/LP_MSPM0G3507/release;..\core\src;..\core\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: ./mspm0g3519.sct
  link misc: "D:\ti\mspm0_sdk_2_11_00_07\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a"
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g351x_uvision.s
  group core
    ../core/src/: zf_device_tft180.c icm42688p.c Grayscale.c drv8873.c encode.c key.c blue.c follow_line.c Q_pid.c MG513XGMR.c
    ../core/inc/: fast_math.h
  group FreeRTOS
    ../freertos/Source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../freertos/Source/portable/GCC/ARM_CM0/: port.c portasm.c
    ../freertos/Source/portable/MemMang/: heap_4.c
    ../: freertos_hooks.c
